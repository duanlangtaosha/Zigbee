# Keil uVision project LCD12864.uvproj, settings and files
target Project (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: LCD12864 +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Head
  group App
    ./: STARTUP.A51
    ./App/: main.c lcd12864.c
