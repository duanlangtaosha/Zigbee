# Keil uVision project Project.uvproj, settings and files
target DS18B20 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Head
  group App
    ./: STARTUP.A51
    ./App/: DS18B20.C LCD1602.c main.c
  group Head
    ./Head/: ds18b20.h lcd1602.h
